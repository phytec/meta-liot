FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://ftpm.cfg"
