RDEPENDS:${PN}:remove = "\
    rauc-downgrade-barrier \
    rauc-hawkbit-updater \
"
